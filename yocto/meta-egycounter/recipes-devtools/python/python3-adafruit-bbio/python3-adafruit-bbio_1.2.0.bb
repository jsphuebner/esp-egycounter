SUMMARY = "Adafruit BBIO library for BeagleBone"
HOMEPAGE = "https://github.com/adafruit/adafruit-beaglebone-io-python"
LICENSE = "CLOSED"

inherit pypi setuptools3

PYPI_PACKAGE = "Adafruit-BBIO"
SRC_URI[sha256sum] = "f6f20b3adfbfe7067ac8b9ac2b33cd807401e33ad0396b079f8c3d323f7fd540"
